# Keil uVision project Gpio_input_registerlevel.uvprojx, settings and files
target stm32f446re (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u6)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gpio_input_registerlevel
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
